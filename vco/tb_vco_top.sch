** sch_path: vco/tb_vco_top.sch
**.subckt tb_vco_top
x1 VCTRL VCO_EN D[6] D[5] D[4] D[3] D[2] D[1] D[0] IN OUT FOUT VDD_INV VDD_DEC 0 vco_top
COUT OUT 0 100f m=1
CFOUT FOUT 0 100f m=1
VDDD VDD_DEC 0 {VDEC}
VDDI VDD_INV 0 {VINV}
VCT VCTRL 0 {VCTRL}
VEN VCO_EN 0 PULSE(0 {VDEC} 2u 10n 10n 1 2)
VIN IN 0 PULSE(0 {VINV} 0.5u 10n 10n 0.5u 1u)
VD0 D[0] 0 {VDEC*0}
VD1 D[1] 0 {VDEC*0}
VD2 D[2] 0 {VDEC*0}
VD3 D[3] 0 {VDEC*0}
VD4 D[4] 0 {VDEC*0}
VD5 D[5] 0 {VDEC*0}
VD6 D[6] 0 {VDEC*0}
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice diode_typical
.include [xschem get current_dirname]/spice/decoder_7to128_ideal.spice



.param VDEC=5.0 VINV=3.3 VCTRL=2.0
.options method=gear reltol=1e-3
.save v(in) v(out) v(fout) v(vco_en) v(vctrl) v(x1.r0) v(x1.r3) v(x1.r6) v(x1.min) v(x1.mout)
.save v(x1.vbp) v(x1.vbn) v(vdd_inv) i(vddi)
.control
let nfail = 0
foreach vc 1.0 1.5 2.0 2.5 3.3
  alterparam VCTRL=$vc
  reset
  tran 0.1n 8u 0 0.2n
  meas tran out_lo find v(out) at=1.4u
  meas tran out_hi find v(out) at=1.9u
  meas tran tr1 when v(fout)=1.65 rise=1 td=4u
  meas tran tr11 when v(fout)=1.65 rise=11 td=4u
  meas tran iavg avg i(vddi) from=4u to=8u
  let vinv = v(vdd_inv)[0]
  if out_lo < 0.9*vinv
    echo FAIL inverter mode: VCTRL=$vc IN=0 OUT=$&out_lo
    let nfail = nfail + 1
  end
  if out_hi > 0.1*vinv
    echo FAIL inverter mode: VCTRL=$vc IN=VINV OUT=$&out_hi
    let nfail = nfail + 1
  end
  let per = (tr11 - tr1)/10
  let fmhz = 1e-6/per
  let ima = -iavg*1e3
  echo VCO: VCTRL=$vc V  period=$&per s  f=$&fmhz MHz  I(VDD_INV)=$&ima mA
  set fn = tb_vco_top_vctrl{$vc}.raw
  write $fn
end
echo
echo ==================================================
if nfail = 0
  echo RESULT: inverter mode PASS
else
  echo RESULT: inverter mode FAIL ($&nfail)
end
echo ==================================================
.endc


**** end user architecture code
**.ends
.end
